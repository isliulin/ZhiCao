# Keil uVision project STM32F103PRJ.uvproj, settings and files
target STM32F103PRJ (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103PRJ +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\CM3;.\FWlib\inc;.\usr
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./startup/: startup_stm32f10x_md.s
  group CMSYS
    ./FWlib/SRC/: system_stm32f10x.c misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
    ./CM3/: core_cm3.c
  group usr
    ./usr/: main.c stm32f10x_it.c SysTickDelay.c Lcd_Driver.c GUI.c key.c Encoder.c TSL1401CCD.c controller.c
